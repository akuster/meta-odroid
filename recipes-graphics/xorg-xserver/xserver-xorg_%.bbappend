PACKAGECONFIG_remove_odroid-c2 = "glamor"

