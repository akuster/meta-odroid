INSANE_SKIP:libgstgl-1.0 = "file-rdeps"
INSANE_SKIP:gstreamer1.0-plugins-base-opengl = "file-rdeps"
